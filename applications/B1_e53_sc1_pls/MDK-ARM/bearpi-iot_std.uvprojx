# Keil uVision project bearpi-iot_std.uvprojx, settings and files
target bearpi-iot_std (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000BFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: bearpi-iot_std +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx
  c include: ../../../Core/Inc;../../../Drivers/STM32L4xx_HAL_Driver/Inc;../../../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../../Drivers/CMSIS/Include;../../../Hardware/LCD;../../../Hardware/FLASH;../../../Hardware/E53_SC1;../../../Hardware/QSPI_FLASH;../../../Hardware/FATFS/App;../../../Hardware/FATFS/Target;../../../Middlewares/Third_Party/FatFs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User/Core
    ../: main.c
    ../../../Core/Src/: gpio.c adc.c dac.c dma.c i2c.c usart.c quadspi.c sdmmc.c spi.c tim.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_qspi.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../../../Core/Src/: system_stm32l4xx.c
  group Hardware
    ../../../Hardware/LCD/: HzLib.c lcd.c
    ../../../Hardware/FLASH/: flash.c
    ../../../Hardware/QSPI_FLASH/: hal_qspi_flash.c
    ../../../Hardware/E53_SC1/: E53_SC1.c
  group Middlewares/FatFs
    ../../../Hardware/FATFS/App/: fatfs.c
    ../../../Hardware/FATFS/Target/: sd_diskio.c bsp_driver_sd.c
    ../../../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
software components: CMSIS:CORE 4.3.0
